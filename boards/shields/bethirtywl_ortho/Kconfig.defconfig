## boards/shields/bethirtywl_ortho/Kconfig.shield
```kconfig
config SHIELD_BETHIRTYWL_ORTHO
    def_bool $(shields_list_contains,bethirtywl_ortho)
```
