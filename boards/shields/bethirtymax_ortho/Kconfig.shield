## boards/shields/bethirtymax_ortho/Kconfig.shield
```kconfig
config SHIELD_BETHIRTYMAX_ORTHO
    def_bool $(shields_list_contains,bethirtymax_ortho)
```
